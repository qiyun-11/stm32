# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10x_HD,USE_STDPERIPH_DRIVER
  c include: .\start;.\Library;.\Users;.\System;.\board;.\Interfcae;.\services;.\Driver;.\Driver\delay;.\Driver\encoder;.\Driver\exti;.\Driver\key;.\Driver\led;.\Driver\oled;.\Driver\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Users
    ./Users/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Board
    ./board/: Board.h
  group Service
    ./services/: Encoder_service.c Encoder_service.h Clock_display.c Clock_display.h Clock_mode.c Clock_mode.h Clock_service.c Clock_service.h
  group Driver
    ./Driver/delay/: Delay.c Delay.h
    ./Driver/encoder/: Encoder_driver.c Encoder_driver.h
    ./Driver/exti/: EXTI_tools.c EXTI_tools.h
    ./Driver/oled/: OLED.c OLED.h OLED_Font.h
    ./Driver/timer/: Tim_base.c Tim_base.h Tim_interrupt.c Tim_interrupt.h
    ./Driver/key/: key_driver.c key_driver.h
    ./Driver/led/: led_gpio_drv.c led_gpio_drv.h led_interface.h
    ./Driver/: isr_stubs.c Driver_error.h
